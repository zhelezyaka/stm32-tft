# Keil uVision project stm32d.uvproj, settings and files
target stm32-lcd (ARM-ADS)
  device: STM32F103ZE STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x807FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: stm32d +hex
  c flags: Optim=1
  c define: USE_STDPERIPH_DRIVER,STM32F10X_HD,USE_STM32100E_EVAL
  c include: ..\Libraries\CMSIS\CM3;..\Libraries\STM32F10x_StdPeriph_Driver\inc;..\Libraries\Embedded_GUI_HAL\inc;..\Libraries\Embedded_GUI_Library\inc;..\User;..\Libraries\STM32_EVAL;..\Libraries\STM32_EVAL\STM32100E_EVAL;..\Libraries\STM32_EVAL\Common
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group CMSIS
    ../Libraries/CMSIS/CM3/: core_cm3.c system_stm32f10x.c
    ../Libraries/CMSIS/CM3/startup/: startup_stm32f10x_hd.s
  group StdPeriph
    ../Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_exti.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_spi.c stm32f10x_flash.c stm32f10x_dma.c stm32f10x_cec.c stm32f10x_i2c.c stm32f10x_pwr.c stm32f10x_usart.c
  group StGui
    ../Libraries/Embedded_GUI_Library/src/: cursor.c gl_fonts.c graphicObject.c images.c
    ../Libraries/Embedded_GUI_Library/inc/: cursor.h gl_fonts.h graphicObject.h graphicObjectTypes.h images.h
  group StGuiHal
    ../Libraries/Embedded_GUI_HAL/src/: JoyHal.c LcdHal.c touchscreen.c TscHal.c
    ../Libraries/Embedded_GUI_HAL/inc/: JoyHal.h LcdHal.h stm32HAL.h touchscreen.h TscHal.h
  group Eval
    ../Libraries/STM32_EVAL/STM32100E_EVAL/: stm32100e_eval.c stm32100e_eval_cec.c stm32100e_eval_fsmc_onenand.c stm32100e_eval_fsmc_sram.c stm32100e_eval_ioe.c
    ../Libraries/STM32_EVAL/Common/: fonts.c
  group Src
    ../User/: main.c stm32f10x_it.c stm32f10x_conf.h stm32f10x_it.h util.c util.h pictures.c pictures.h hw_config.c menu.c hw_config.h menu.h
  group Lcd
    ../User/: ili9325.c ili9325.h colors.h reg.h
  group Touch
    ../User/: xpt2046.c xpt2046.h
